# Keil uVision project Encoder_Lite2_bk2.uvproj, settings and files
target Encoder_Lite2 (MCS-251)
  device: AI32G12K128 Series AI
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Encoder_Lite2 +hex
  link misc: REMOVEUNUSED
  group AiCube
    ./Sources/: main.c port.c clock.c wdt.c timer.c spi.c can.c mathlib.c
    ./Sources/lib/: stc32_mdu32_large.lib
