# Keil uVision project F042600.uvprojx, settings and files
target F042600 (6240000::V6.24::ARMCLANG)
  device: STM32F042G6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: F042600 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F042x6
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../User/Task;../User/Device;../User/Middleware;../User;../User/Middleware/Algorithm;../User/Middleware/Driver;../Middlewares/Third_Party/ARM/DSP;../Middlewares/ST/ARM/DSP/Src;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c i2c.c iwdg.c spi.c tim.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_can.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Middlewares/Algorithm
    ../User/Middleware/Algorithm/: alg_pid.cpp alg_pid.h alg_power_limit.cpp alg_power_limit.h
  group Middlewares/Drivers
    ../User/Middleware/Driver/: drv_can.cpp drv_can.h drv_dwt.cpp drv_dwt.h drv_math.cpp drv_math.h drv_tim.cpp drv_tim.h drv_crclite.h drv_crclite.cpp
  group Devices
    ../User/Device/: dvc_djimotor.cpp dvc_djimotor.h dvc_ma600_spi.cpp dvc_ma600_spi.h dvc_as5600.cpp
    ../User/Task/: dvc_as5600_3.h
  group Task
    ../User/Task/: task.cpp task.h alg_filter.cpp alg_filter.h dvc_as5600_3.h
software components: CMSIS:CORE 6.1.0
